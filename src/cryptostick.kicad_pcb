# Repository Nitrokey/nitrokey-pro-hardware

File README:

Crypto Stick v1 PCB Design

							    Version 0.1
							     2014-01-17
						               Jan Suhr

Introduction
==============

Crypto Stick is a USB 32-bit computer with STM32F103 processor and
an OpenPGP smart card. It has a minimalistic design, the MCU is running
at 72MHz, and it has a SWD port for main flash ROM update.

This is Crypto Stick v1 PCB design for KiCAD, based on Niibe
Yutaka's Flying Stone Tiny 01 (FST-01).

Files
=====

    README:           This file
    BOM.csv           Part list including Digikey product number.
    ChangeLog:        History of this project
    cryptostick.pro:  Project file of KiCAD
    cryptostick.sch:  Schematic
    cryptostick.cmp:  Component
    cryptostick.net:  Netlist
    cryptostick.stf:  Component and Module
    cryptostick.brd:  PCB design
    library:          schematic library
    module:           footprint modules for PCB
    gerber:           Gerber files of the PCB
    datasheet:        Datasheets of parts

Note that files under datasheet directory is copyrighted by vendors.

Terms and conditions
====================

This work is based on Niibe Yutaka's Flying Stone Tiny 01 (FST-01) PCB Design.

I would like to ask users to keep the design as "Open Hardware".  See
the page for the definition of "Open Hardware":

    http://www.opencollector.org/Whyfree/open_hardware.html

Nevertheless, schematic design is distributed under Creative Commons
Attribution 3.0 Unported License (CC BY 3.0).  See:

    http://creativecommons.org/licenses/by/3.0/

Schematic design can be used for any purpose and you don't need to
open your modifications to my design.

For PCB, it is distributed under Creative Commons
Attribution-ShareAlike 3.0 Unported (CC BY-SA 3.0).  See:

    http://creativecommons.org/licenses/by-sa/3.0/

External modules
================

For module/SMT_CAP.mod and module/SMT_RES.mod, module drawings are
copied from w_smd_cap.mod and w_smd_resistors.mod by W.Lain.  Files
are available at:

   http://smisioto.no-ip.org/elettronica/kicad/kicad-en.htm

Its copyright notice is like following:
---------------------------------------------------------------------
Kicad Library by W. Lain - kcswalter@member.fsf.org

This library is released under the terms of the Creative Commons
license v3.0, Attribution-Share Alike.

The author holds no responsibility for any damage that can be caused
by the usage of this library. You are however welcome to report any
error or discrepance to the author, provided that you give also the
correct information and its source (i.e. the correct datasheet).

Note that the author used publicly available data sheets from many
different companies, and that package dimensions, pin numeration and
schematic symbols may vary slightly between companies.
---------------------------------------------------------------------

Flashing
========

This hardware can be flashed in two different ways:

* SWD protocol requires a separate programmer such as the ST-Link V2 (or cheaper clones). The SWD port or the Nitrokey PCB are the four blank contact points. You can either solder four wires or build your own adapter (see directory cs_pogo_adapter).

* A bit easier would be to use DFU. It requires a serial/TTL port (perhaps you need a serial/TTL-USB adapter) and a simple adapter. The DFU port is routed to the USB plug. Your adapter should consist of a USB socket which four pins are connected to your serial/TTL connector. The pinout is as follows.

Nitrokey USB Plug <-> Serial/TTL adapter

Pin 1, VCC <-> VCC
Pin 2, D-  <-> TX
Pin 3, D+  <-> RX
Pin 4, GND <-> GND

This diagram represents the pinout of the USB socket which you are going to solder:

  ################### 
  #                 # 
  # ############### # 
  #                 # 
  #                 # 
  ################### 
     #   #   #   #   
     #   #   #   #    

     1   2   3   4

To flash the firmware you need to bridge the two contact holes (e.g. with a wire) and only then connect (and power) the PCB to your adapter. The bridge triggers the hardware to boot into DFU mode. You may use [STM32 Flash Loader Demonstrator](http://www.st.com/content/st_com/en/products/development-tools/software-development-tools/stm32-software-development-tools/stm32-programmers/flasher-stm32.html) (Windows only) or the open source command line tool [stm32flash](http://stm32flash.sourceforge.net).

## KiCad design src/cryptostick.kicad_pcb

Parts:
C1, C2: 27pF; C_0402_1005Metric
C3, C4, C5, C6, C7, C8: 0.1uF; C_0402_1005Metric
C9, C11: 4.7uF; C_0402_1005Metric
C10: 0.01uF; C_0402_1005Metric
D1: DUAL_LED; KPHBM-2012SURKCGKC
J1: SIM_JACKET; molex 78646-3001
J2: USB_A; USB-A-PLUG
JT1: CONN_4; SIL-2-2-drilled-offset
R1, R2: 510; R_0402_1005Metric
R3, R4: 10k; R_0402_1005Metric
R5, R6: 22; R_0402_1005Metric
R7: 1.5k; R_0402_1005Metric
R8: 20k; R_0402_1005Metric
U1: STM32F103TB; QFN-36-1EP_6x6mm_P0.5mm_EP4.1x4.1mm_ThermalVias
U2: CAT6217-330; TSOT-23-5
U3: DF5A5.6JE; SOT-553
X1: 12MHz; ABM8G
p1, p2, p3, p5, p6: debug-pin; Prog_Pad_Circular
p4: PROG_VCC; Prog_Pad_Circular

Connections:
+3.3V: C4.2, C6.2, C7.2, C8.2, C9.1, JT1.1, U1.1 (VDD_3), U1.6 (VDDA), U1.19 (VDD_1), U1.27 (VDD_2), U2.5 (VOUT)
/BOOT0: R4.1, U1.35 (BOOT0)
/BOOT1: R3.2, U1.17 (BOOT1)
/D+: R6.1, U1.21 (PA9), U1.24 (USB_DP)
/D+_PLUG: J2.3, R6.2, R7.2, U3.5 (C4), p2.1 (p)
/D-: R5.1, U1.22 (PA10), U1.23 (USB_DM)
/D-_PLUG: J2.2, R5.2, U3.4 (C3), p3.1 (p)
/NRST: C3.1, U1.4 (NRST)
/OSC_IN: C1.1, U1.2 (OSC_IN), X1.1
/OSC_OUT: C2.1, U1.3 (OSC_OUT), X1.2
/SCCLK: J1.3 (CLK), U1.20 (PA8)
/SCRST: J1.2 (RST), U1.30 (PB3)
/SCSDA: J1.7 (SDA), R8.2, U1.33 (PB6)
/SCVCC: C5.1, J1.1 (Vcc), R8.1, U1.31 (PB4), U1.32 (PB5)
/SWCLK: JT1.3, U1.28 (SWCLK), p5.1 (p)
/SWDIO: JT1.4, U1.25 (SWDIO), p6.1 (p)
/USB_EN: R7.1, U1.29 (PA15)
/VBUS: C11.1, J2.1, U2.1 (VIN), U2.3 (EN), U3.3 (C2), p4.1 (p)
GND: C1.2, C2.2, C3.2, C4.1, C5.2, C6.1, C7.1, C8.1, C9.2, C10.2, C11.2, D1.2 (K1), D1.3 (A2), J1.5 (GND), J2.4, JT1.2, R3.1, R4.2, U1.5 (VSSA), U1.18 (VSS_1), U1.26 (VSS_2), U1.36 (VSS_3), U1.37 (GND), U2.2 (GND), U3.2 (GND), X1.3 (GND), p1.1 (p)
unnamed: D1.1 (A1), R1.1
unnamed: D1.4 (K2), R2.1
unnamed: R1.2, U1.14 (PA7)
unnamed: R2.2, U1.15 (PB0)
unnamed: C10.1, U2.4 (BYP)

Board: 2 copper layers, 21.8 x 16.3 mm, 37 parts (5 on the bottom side), 24 nets.

Other parts of the board:
FID1, FID2, FID3, FID4: Fiducial_0.5mm_Dia_1mm_Outer

File BOM.csv:

"Id";"Designator";"Package";"Quantity";"Designation";"Digikey Part Number";"Digikey URL"
1;"JP1";"boot";1;"JUMPER";"n.a.";
2;"P1";"SIL-2-2";1;"CONN_4";"n.a.";
3;"C3,C7,C6,C5,C4,C8";"c_0402";6;"0.1uF";"No tantalum, tolerance 20%, temperature -20 to +70 °C.";"http://www.digikey.com/product-detail/en/C1005X7R1C104M050BC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"
4;"R1,R2";"r_0402";2;510;"2% tolerance, temperature -20 to +70 °C.";"http://www.digikey.com/product-detail/en/RC0402FR-07510RL/31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"
5;"C1,C2";"c_0402";2;"27pF";"No tantalum, tolerance 20%, temperature -20 to +70 °C.";"http://www.digikey.com/product-detail/en/C1005C0G1H270J050BA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"
6;"C9,C11";"c_0402";2;"4.7uF";"No tantalum, tolerance 20%, temperature -20 to +70 °C.";"http://www.digikey.com/product-detail/en/C1005X5R1A475M050BC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"
7;"U2";"TSOT23-5";1;"CAT6217-330";"576-2835-1-ND or ADP121-AUJZ33R7CT-ND";"http://www.digikey.com/product-detail/en/MIC5265-3.3YD5%20TR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"
8;"U1";"QFN36";1;"STM32F103TB";"497-11534-ND";"http://www.digikey.com/product-search/en?vendor=0&keywords=4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"
9;"X1";"ABM8G";1;"12MHz";"535-10283-1-ND";"http://www.digikey.com/product-detail/en/ABM8G-12.000MHZ-B4Y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"
10;"R3,R4";"c_0402";2;"10k";"2% tolerance, temperature -20 to +70 °C.";"http://www.digikey.com/product-detail/en/RC0402FR-0710KL/311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"
11;"C10";"c_0402";1;"0.01uF";"No tantalum, tolerance 20%, temperature -20 to +70 °C.";"http://www.digikey.com/product-detail/en/C1005X7R1E103K050BB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"
12;"U3";"SOT363";1;"NUF2221W1";"NUF2221W1T2GOSCT-ND";"http://www.digikey.com/product-detail/en/NUF2221W1T2G/NUF222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"
13;"J2";"USB-A-PLUG";1;"USB_A";"WM3983TR-ND";"http://www.digikey.com/product-detail/en/0480372200/WM3983CT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"
13;;;;;"Alternative: Keystone 931K-ND";"http://octopart.com/931-keystone-7166852"
14;"D1";"KPHBM-2012SURKCGKC";1;"DUAL_LED";"element14.com 1686079RL";"http://www.digikey.com/product-detail/en/APHBM2012SURKCGKC/7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"
15;"J1";"Molex 0786463001";1;"SIM_JACKET";"WM9364CT-ND";"http://www.digikey.com/product-detail/en/0786463001/WM9364CT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"

## KiCad design cs_pogo_adapter/cs_pogo_adapter.kicad_pcb

File cs_pogo_adapter/README.txt:

J8 and J9 are different types of pads used on different target PCBs. They are all connected together to make testing easier.

R1 and R2 are required depending on whether you use Versaloon or ST-Link programmer.

R1 is used to power the target device when using ST-Link. ST-Link doesn't provide power to the target board normally, but it has 3.3V on pin 19 of the JTAG connector (which is normally not connected on the target board).

R2 is used to power the target device when using Versaloon. I think Versaloon can power the target through pin 1 of the JTAG connector, but I'm not sure.

J4 and J7 are obsolete and should be removed.

Parts:
J1, J5, J6: HEADER_6
J2: HEADER_10X2
J3, J4, J7, J8, J9: HEADER_4
R1: 0

Connections:
+3.3V: J2.19, R1.1
/SWCLK: J1.4, J2.9, J3.3, J4.3, J5.4, J6.4, J7.3, J8.3, J9.3
/SWIO: J1.5, J2.7, J3.4, J4.4, J5.5, J6.5, J7.4, J8.4, J9.4
/TVCC: J2.1; also elsewhere on the board
GND: J1.3, J2.12, J2.18, J2.20, J3.2, J4.2, J5.3, J6.3, J7.2, J8.2, J9.2
VCC: J1.2, J3.1, J4.1, J5.2, J6.2, J7.1, J8.1, J9.1, R1.2; also elsewhere on the board

Board: 2 copper layers, 26.0 x 42.0 mm, 10 parts (0 on the bottom side), 6 nets.

Other parts of the board:
R2: 0; r_0805

Their connections:
/TVCC: R2.1; also elsewhere on the board
VCC: R2.2; also elsewhere on the board

## Commit log

2014-01-17 initial version
2014-02-27 New PCB layout. Changed programming connector. Added uart to USB connector. Moved LED to other side.
2014-03-02 Changed boot0 jumper to THT. Decreased VDD via size.
2014-03-02 Cleaning repo.
2014-03-03 Updated BOM with Digikey links
2014-03-07 Fixed silkscreen.
2014-06-22 Added programmer adapter baord project.
2014-06-25 USB plug updated
2014-06-27 README.txt added
2014-11-03 Keystone USB plug removed
2014-11-25 slots for lands of casing added
2014-12-04 LED moved and 3D model added
2014-12-05 obsolete module removed
2014-12-17 IDF added
2014-12-22 USB plug shifted and tolerances added to IDF
2014-12-22 molex and usb height tolerances
2014-12-23 usb +molex height tolerances
2015-01-08 slots resized from 1mm to 0.7mm
2015-01-27 pitch of programmer pads changed; slots changed to 0.7mm
2015-04-08 resize pcb, moved usb plug
2015-04-08 structured idf readme
2015-04-27 0.5mm longer
2015-04-27 PDF addedd
2015-04-27 P&P fixed
2015-04-27 extended PCB by 0.5mm
2015-04-28 USB position
2016-07-27 flashing procedures and pinout described
2017-12-06 Pads under USB provided
    USB connection exposed as pin pads, similarly how we did it at the last
    hardware (FIDO U2F)
2018-03-31 DRC errors have been fixed on the original design:
    - gnd power source has been added
    - conflicted pin types changed to bidirectional
2018-04-04 V2
    - ESD protcetion IC changed from NUF221W1 to DF5A5.6JE
    - USB terminating and enable resistors have been added
    - USB connector footprint has been corrected
    - Many duplicated footrpints and tracks have been deleted
    - GND plane on TOP side mistakenly wasnt connected to GND net.
    Corrected.
2018-07-01 V3: - ATECC508 crypto engine - Touch button, SIM jacket used as a touch pad, MTCH101 touch controller (same as used with Nitrokey U2F FIDO stick)
2018-07-01 V3
    - ATECC508 crypto engine
    - Touch button, SIM jacket used as a touch pad, MTCH101 touch controller (same as used with Nitrokey U2F FIDO stick)
2018-07-04 Nitrokey Start
    - SIM jack replaced with a touch button pad
2018-10-01 Pick and place file added
2018-12-11 Change Readme file extension to Markdown
2018-12-11 Change formatting to Markdown and add comment regarding DFU flashing
2018-12-11 Add connector drawing and flashing description
2018-12-11 Reduce image size
2018-12-14 Update README.md
    Correct formatting in sections:
    - Flashing / DFU
    - External modules / copyright notice
2018-12-14 Update README.md
    Remove header with author and version
2018-12-14 Update README.md
    Correct headline
2018-12-14 Update README.md
    Correct headline - 2
2018-12-21 ticks added
2019-01-10 Correct pinout of Debug connector add note about data loss when flashing
2019-01-10 make connector drawing smaller
2019-01-10 Add stylized USB connector for reference
2019-01-10 Fix Connector layout and add note about data loss (#14)
    * Correct pinout of Debug connector add note about data loss when flashing
    * make connector drawing smaller
    * make connector drawing smaller
    * Add stylized USB connector for reference
2019-01-25 Corrections of fabrication data
2019-02-01 Pick & place files updated
2019-02-01 removing flashing instructions and reference to firmware repo
2021-06-16 Modifications for pro rev4 with BGA
2021-06-16 Add panelized pcb file, generation script, and gerbers
2021-06-16 Update panel alignment marks to match previous panel
2025-06-06 Nk Pro v6 - update to KiCad v9 - add smartcard pullup (R8) - update panelization - update outputs
2025-06-19 Add Rev7 (BGA with smartcard pullup), update production files and panelization script.
2025-06-20 Add Rev7 (BGA with smartcard pullup), update production files and panelization script. (#23)
2025-06-20 Nk Pro v6 (#22)
    - update to KiCad v9
    - add smartcard pullup (R8)
    - update panelization
    - update outputs
2026-05-08 Add hardware revisions to README
